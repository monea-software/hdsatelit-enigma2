FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append:h8 = " file://0001-romblock-refuse-negative-mapped-offset.patch"
