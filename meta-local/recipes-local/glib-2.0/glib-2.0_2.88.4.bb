# Copiat din openembedded-core (ramane sub licenta MIT a stratului openembedded-core), pentru glib-2.0 2.88.4;
# glib.inc din acest dosar, cu antetul lui (de ce 2.88.4 si ce repara).
require glib.inc

