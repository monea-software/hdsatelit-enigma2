# Copyright (C) 2026 moneasoftware.com (Monea Eduard) & hdsatelit.com (HD Satelit)
# SPDX-License-Identifier: GPL-2.0-only
#
# NUMAI pentru stratul OE-Alliance 6.0 (pregateste-strat-60.sh il pune peste meta-local). libdca (ceruta de ffmpeg-ext, pentru exteplayer3), numai pentru feed. Reteta OE-Alliance
# ia ultima comitere la fiecare constructie (AUTOREV); aici e fixata comiterea pachetelor ServiceApp construite si probate
# pe .122 pe 11.11.2026 (lucru-sesiune/paralel-1111/STADIU-A-SERVICEAPP.md, copii-receptor-161/serviceapp-074-*-1111).
# O comitere mai noua: SRCREV schimbat aici si proba ServiceApp din nou (teste/proba_serviceapp_122.py).
SRCREV = "95c4bd8baee808ec563120f463111e2cd6cd240e"
