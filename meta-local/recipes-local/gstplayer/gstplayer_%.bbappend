# Copyright (C) 2026 moneasoftware.com (Monea Eduard) & hdsatelit.com (HD Satelit)
# SPDX-License-Identifier: GPL-2.0-only
#
# NUMAI pentru stratul OE-Alliance 6.0 (pregateste-strat-60.sh il pune peste meta-local). gstplayer (fluxurile 5001 ale ServiceApp), numai pentru feed; depozitul de pe gitlab nu s-a mai schimbat din 04.02.2017. Reteta OE-Alliance
# ia ultima comitere la fiecare constructie (AUTOREV); aici e fixata comiterea pachetelor ServiceApp construite si probate
# pe .122 pe 11.11.2026 (lucru-sesiune/paralel-1111/STADIU-A-SERVICEAPP.md, copii-receptor-161/serviceapp-074-*-1111).
# O comitere mai noua: SRCREV schimbat aici si proba ServiceApp din nou (teste/proba_serviceapp_122.py).
SRCREV = "3beb10950bb79977339d9ca6c638bf962392fca4"
