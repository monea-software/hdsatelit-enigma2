# DX5: the native pairing screen requires the client and both HID transports.
PACKAGECONFIG:append:gbquad4kpro = " readline hid-profiles hog-profiles"
